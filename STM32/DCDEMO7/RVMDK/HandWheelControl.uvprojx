# Keil uVision project HandWheelControl.uvprojx, settings and files
target HandWheel (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HMI_M3DEMO +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\..\..\Libraries\CMSIS\Core\CM3;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL;..\inc;..\inc;..\inc;..\inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../src/: hw_config.c stm32f10x_it.c main.c ulitity.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_tim.c
  group RVMDK
    ../../../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../../../Libraries/CMSIS/Core/CM3/: system_stm32f10x.c core_cm3.c
  group Doc
    ../: readme.txt
  group HMI_DRIVE
    ../src/: hmi_user_uart.c cmd_queue.c hmi_driver.c flash.c malloc.c TFT.c cJSON.c timer.c exti.c key.c IIC.c 24C02.c
